# Keil uVision project HWatchFX.uvprojx, settings and files
target HWatchFX (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: HWatchFx +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/User;../Gui/Fonts;../Drivers/GUI_Lib;../Drivers/GUI_Lib/lvgl/master;../Drivers/GUI_Lib/lvgl/master/src;../Drivers/GUI_Lib/lvgl/lvgl_driver;../Gui;../Drivers/Ardu_Lib;../Arduboy_Game/Snake;../Arduboy_Game/FlappyBall;../Arduboy_Game/Buttons;../Drivers/GUI_Lib/lvgl/master/src/misc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/User/Core
    ../Core/Inc/: tim_handler.h dma_handler.h
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group StartUp
    ./: startup_stm32f103xe.s
  group Drivers/User
    ../Drivers/User/: lcd_1inch28.c system_info.c hdc1080.c bmp280.c stm32_ds3231.c buzzer.c w25q16.c devices.h key.h devices.c calculator.c device_config.c comm.c
  group BSP
    ../Core/Inc/: system.h delay.h
    ../Core/Src/: delay.c
  group Application/User/Gui
    ../Drivers/GUI_Lib/: GUI_Paint.c
    ../Gui/: gui_inc.h gui_port.c gui_main.c gui_apps.c gui_calc.c gui_game.c gui_canlendar.c gui_setting.c gui_stopwatch.c gui_about.c gui_logo.c
    ../Gui/Fonts/: hwatch_symbol_def.h hwatch_icons_font_16.c
  group Lvgl
    ../Drivers/GUI_Lib/lvgl/master/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Drivers/GUI_Lib/lvgl/master/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Drivers/GUI_Lib/lvgl/master/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Drivers/GUI_Lib/lvgl/master/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Drivers/GUI_Lib/lvgl/master/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../Drivers/GUI_Lib/lvgl/master/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Drivers/GUI_Lib/lvgl/master/src/extra/themes/default/: lv_theme_default.c
    ../Drivers/GUI_Lib/lvgl/master/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Drivers/GUI_Lib/lvgl/master/src/extra/widgets/chart/: lv_chart.c
    ../Drivers/GUI_Lib/lvgl/master/src/extra/widgets/list/: lv_list.c
    ../Drivers/GUI_Lib/lvgl/master/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Drivers/GUI_Lib/lvgl/master/src/extra/widgets/spinner/: lv_spinner.c
    ../Drivers/GUI_Lib/lvgl/master/src/extra/widgets/tabview/: lv_tabview.c
    ../Drivers/GUI_Lib/lvgl/master/src/extra/layouts/flex/: lv_flex.c
    ../Drivers/GUI_Lib/lvgl/master/src/extra/layouts/grid/: lv_grid.c
    ../Drivers/GUI_Lib/lvgl/master/src/extra/: lv_extra.c
    ../Drivers/GUI_Lib/lvgl/master/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../Drivers/GUI_Lib/lvgl/master/src/extra/widgets/span/: lv_span.c
    ../Drivers/GUI_Lib/lvgl/master/src/extra/widgets/meter/: lv_meter.c
  group Lvgl/Port
    ../Drivers/GUI_Lib/lvgl/lvgl_driver/: lv_port_disp.c lv_port_indev.c lv_port_disp.h lv_port_indev.h
    ../Drivers/GUI_Lib/lvgl/master/: lv_conf.h
  group Arduboy
    ../Drivers/Ardu_Lib/: arduboy.c arduboy.h arduboy_core.c arduboy_core.h
  group Arduboy/Snake
    ../Arduboy_Game/Snake/: Constants.h Food.cpp Food.h Snake.cpp Snake.h SnakePort.cpp SnakePort.h Sprites.h
  group Arduboy/FlappyBall
    ../Arduboy_Game/FlappyBall/: bitmaps.h FlappyBall.c FlappyBall.h
  group Arduboy/Buttons
    ../Arduboy_Game/Buttons/: ArduboyButtons.c ArduboyButtons.h
software components: CMSIS:CORE 4.3.0
